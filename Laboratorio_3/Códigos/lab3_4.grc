options:
  parameters:
    author: KevinSandoval_EduardoCaballero
    generate_options: qt_gui
    id: Trasmisor_AM
    output_language: python
    title: Trasmisor_AM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud Portadora
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.2'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Ka
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '2'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '50000000'
    step: 1e6
    stop: 2.2e9
    value: '50000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: CalculoPotenciaComunicaciones_0
  id: CalculoPotenciaComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: Modulador_AM_D1B_0
  id: Modulador_AM_D1B
  parameters:
    Ac: Ac
    kA: Ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dev_args: '""'
    gain0: GTX
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Modulador_AM_D1B_0, '0', blocks_complex_to_real_0, '0']
- [Modulador_AM_D1B_0, '0', qtgui_time_sink_x_0, '0']
- [Modulador_AM_D1B_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Modulador_AM_D1B_0, '0']
- [blocks_complex_to_real_0, '0', CalculoPotenciaComunicaciones_0, '0']

metadata:
  file_format: 1
