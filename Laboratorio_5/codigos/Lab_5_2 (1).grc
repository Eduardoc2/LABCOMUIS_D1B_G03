options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: punto_1_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: d
  id: variable_qtgui_range
  parameters:
    label: ancho de pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: d1
  id: variable_qtgui_range
  parameters:
    label: delay1
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: d2
  id: variable_qtgui_range
  parameters:
    label: delay2
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: d3
  id: variable_qtgui_range
  parameters:
    label: delay3
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: relacion de frecuencia
    rangeType: int
    start: '0'
    step: '1'
    stop: '1000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: ModuladorPAM_0
  id: ModuladorPAM
  parameters:
    fs: fs
    samp_rate: '100000'
    w: '10'
  states: {}
- name: ModuladorPAM_0_0
  id: ModuladorPAM
  parameters:
    fs: fs
    samp_rate: '100000'
    w: '10'
  states: {}
- name: ModuladorPAM_0_1
  id: ModuladorPAM
  parameters:
    fs: fs
    samp_rate: '100000'
    w: '10'
  states: {}
- name: ModuladorPAM_0_2
  id: ModuladorPAM
  parameters:
    fs: fs
    samp_rate: '100000'
    w: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: d1
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: d2
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: d3
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 100e3
    fc: '0'
    fftsize: 1024*8
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ModuladorPAM_0, '0', blocks_delay_0, '0']
- [ModuladorPAM_0_0, '0', blocks_add_xx_0, '0']
- [ModuladorPAM_0_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorPAM_0_1, '0', blocks_delay_0_0, '0']
- [ModuladorPAM_0_2, '0', blocks_delay_0_1, '0']
- [analog_sig_source_x_0, '0', ModuladorPAM_0_0, '0']
- [analog_sig_source_x_0_0, '0', ModuladorPAM_0, '0']
- [analog_sig_source_x_0_1, '0', ModuladorPAM_0_1, '0']
- [analog_sig_source_x_0_1_0, '0', ModuladorPAM_0_2, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_1, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0, '3']

metadata:
  file_format: 1
