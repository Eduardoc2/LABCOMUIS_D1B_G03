options:
  parameters:
    author: '2181572'
    generate_options: qt_gui
    id: Lab02comu1_grupo03
    output_language: python
    title: configuracionUSRP
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud señal TX
    orient: Qt.Horizontal
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '0.25'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    orient: Qt.Horizontal
    start: 50e6
    step: '1000000'
    stop: 2.2*1000000000
    value: 50e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc
    dev_args: '""'
    gain0: GTX
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
